# Keil uVision project SkyStar_Boot.uvprojx, settings and files
target SkyStar_Boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x8007FFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SkyStar_Boot +hex
  c flags: Optim=3 uC99=1
  c define: STM32F407xx
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  group Boot
    ./: boot_main.c system_boot.c boot_hw.c boot_w25q.c boot_flash.c boot_ota.c startup_stm32f407xx.s
