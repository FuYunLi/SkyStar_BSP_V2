# Keil uVision project SkyStar_BSP_HAL.uvprojx, settings and files
target SkyStar_BSP_HAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SkyStar_BSP_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LWRB_DISABLE_ATOMIC,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/Board;../BSP/Interface;../App;../Middleware/MultiTimer;../Middleware/LwRB/include;../Middleware/letter-shell-shell3.1/src;../Middleware/Easylogger/inc;../BSP/Driver;../APP/demos;../Middleware/MultiButton;../APP/tasks;../BSP/Driver/LibDriver/AT24Cxx/src;../BSP/Driver/LibDriver/AT24Cxx/interface;../BSP/Driver/LibDriver/AT24Cxx/example;../Middleware/LittleFS;../Middleware/lvgl;../Middleware/lvgl/src;../Middleware/lvgl/examples/porting;../BSP/Driver/LibDriver/AHT20/src;../BSP/Driver/LibDriver/AHT20/interface;../BSP/Driver/LibDriver/AHT20/example;../BSP/Driver/LibDriver/INA226/src;../BSP/Driver/LibDriver/INA226/interface;../BSP/Driver/LibDriver/INA226/example;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middleware/Ymodem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\SkyStar_BSP_HAL\SkyStar_BSP_HAL.sct
  link misc: --keep=*.o(shellCommand)
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Inc/: main.h gpio.h stm32f4xx_it.h stm32f4xx_hal_conf.h
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c bsp_driver_sd.h sd_diskio.h fatfs_platform.h ffconf.h
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c fatfs.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middleware/MultiTimer
    ../Middleware/MultiTimer/: MultiTimer.c MultiTimer.h multi_timer_port.c
  group Middleware/LwRB
    ../Middleware/LwRB/lwrb/: lwrb.c lwrb_ex.c
    ../Middleware/LwRB/include/lwrb/: lwrb.h
  group Middleware/LetterShell
    ../Middleware/letter-shell-shell3.1/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell.h shell_cfg.h shell_ext.h
  group Middleware/Easylogger
    ../Middleware/Easylogger/src/: elog.c elog_utils.c elog_async.c elog_buf.c
    ../Middleware/Easylogger/port/: elog_port.c
    ../Middleware/Easylogger/inc/: elog.h elog_cfg.h
  group Middleware/MultiButton
    ../Middleware/MultiButton/: multi_button.c multi_button.h
  group Middleware/LittleFS
    ../Middleware/LittleFS/: lfs.c lfs.h lfs_util.c lfs_util.h
  group Middleware/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c diskio.h ff.h ff_gen_drv.h integer.h
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middleware/LVGL
    ../Middleware/lvgl/: lv_conf.h lvgl.h lvgl_private.h lv_version.h
    ../Middleware/lvgl/src/core/: lv_global.h lv_group.c lv_group.h lv_group_private.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_class_private.h lv_obj_draw.c lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.c lv_obj_event.h lv_obj_event_private.h lv_obj_id_builtin.c lv_obj_pos.c lv_obj_pos.h lv_obj_private.h lv_obj_property.c lv_obj_property.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_refr_private.h
    ../Middleware/lvgl/src/display/: lv_display.c lv_display.h lv_display_private.h
    ../Middleware/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_3d.c lv_draw_3d.h lv_draw_arc.c lv_draw_arc.h lv_draw_buf.c lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.c lv_draw_image.h lv_draw_image_private.h lv_draw_label.c lv_draw_label.h lv_draw_label_private.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_mask_private.h lv_draw_private.h lv_draw_rect.c lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.c lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.c lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
    ../Middleware/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888_premultiplied.h lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565_swapped.h lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb888.h
    ../Middleware/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_grad.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_mask_rect.c lv_draw_sw_private.h lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_utils.h lv_draw_sw_vector.c
    ../Middleware/lvgl/src/font/: lv_binfont_loader.c lv_binfont_loader.h lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_fmt_txt_private.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
    ../Middleware/lvgl/src/indev/: lv_indev.c lv_indev.h lv_indev_gesture.c lv_indev_gesture.h lv_indev_gesture_private.h lv_indev_private.h lv_indev_scroll.c lv_indev_scroll.h
    ../Middleware/lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
    ../Middleware/lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
    ../Middleware/lvgl/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
    ../Middleware/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
    ../Middleware/lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
    ../Middleware/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c lv_fsdrv.h
    ../Middleware/lvgl/src/libs/gif/: gifdec.c gifdec.h gifdec_mve.h lv_gif.c lv_gif.h lv_gif_private.h
    ../Middleware/lvgl/src/libs/lodepng/: lodepng.c lodepng.h lv_lodepng.c lv_lodepng.h
    ../Middleware/lvgl/src/libs/qrcode/: lv_qrcode.c lv_qrcode.h lv_qrcode_private.h qrcodegen.c qrcodegen.h
    ../Middleware/lvgl/src/libs/rle/: lv_rle.c lv_rle.h
    ../Middleware/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
    ../Middleware/lvgl/src/libs/tjpgd/: lv_tjpgd.c lv_tjpgd.h tjpgd.c tjpgd.h tjpgdcnf.h
    ../Middleware/lvgl/src/: lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_conf_internal.h lv_conf_kconfig.h lv_init.c lv_init.h lvgl.h lvgl_private.h
    ../Middleware/lvgl/src/misc/cache/class/: lv_cache_class.h lv_cache_lru_ll.c lv_cache_lru_ll.h lv_cache_lru_rb.c lv_cache_lru_rb.h
    ../Middleware/lvgl/src/misc/cache/instance/: lv_cache_instance.h lv_image_cache.c lv_image_cache.h lv_image_header_cache.c lv_image_header_cache.h
    ../Middleware/lvgl/src/misc/cache/: lv_cache.c lv_cache.h lv_cache_entry.c lv_cache_entry.h lv_cache_entry_private.h lv_cache_private.h
    ../Middleware/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_private.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_area_private.h lv_array.c lv_array.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_bidi_private.h lv_circle_buf.c lv_circle_buf.h lv_color.c lv_color.h lv_color_op.c lv_color_op.h lv_color_op_private.h lv_event.c lv_event.h lv_event_private.h lv_fs.c lv_fs.h lv_fs_private.h lv_grad.c lv_grad.h lv_iter.c lv_iter.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_matrix.c lv_matrix.h lv_palette.c lv_palette.h lv_profiler.h lv_profiler_builtin.c lv_profiler_builtin.h lv_profiler_builtin_private.h lv_rb.c lv_rb.h lv_rb_private.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_style_private.h lv_templ.c lv_templ.h lv_text.c lv_text.h lv_text_ap.c lv_text_ap.h lv_text_private.h lv_timer.c lv_timer.h lv_timer_private.h lv_tree.c lv_tree.h lv_types.h lv_utils.c lv_utils.h
    ../Middleware/lvgl/src/osal/: lv_cmsis_rtos2.c lv_cmsis_rtos2.h lv_freertos.c lv_freertos.h lv_linux.c lv_linux_private.h lv_mqx.c lv_mqx.h lv_os.c lv_os.h lv_os_none.c lv_os_none.h lv_os_private.h lv_pthread.c lv_pthread.h lv_rtthread.c lv_rtthread.h lv_sdl2.c lv_sdl2.h lv_windows.c lv_windows.h
    ../Middleware/lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
    ../Middleware/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager.h lv_font_manager_recycle.c lv_font_manager_recycle.h
    ../Middleware/lvgl/src/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c lv_fragment_private.h
    ../Middleware/lvgl/src/others/gridnav/: lv_gridnav.c lv_gridnav.h
    ../Middleware/lvgl/src/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
    ../Middleware/lvgl/src/others/imgfont/: lv_imgfont.c lv_imgfont.h
    ../Middleware/lvgl/src/others/monkey/: lv_monkey.c lv_monkey.h lv_monkey_private.h
    ../Middleware/lvgl/src/others/observer/: lv_observer.c lv_observer.h lv_observer_private.h
    ../Middleware/lvgl/src/others/snapshot/: lv_snapshot.c lv_snapshot.h
    ../Middleware/lvgl/src/others/sysmon/: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
    ../Middleware/lvgl/src/others/xml/: lv_xml.c lv_xml.h lv_xml_base_types.c lv_xml_base_types.h lv_xml_component.c lv_xml_component.h lv_xml_component_private.h lv_xml_parser.c lv_xml_parser.h lv_xml_private.h lv_xml_style.c lv_xml_style.h lv_xml_update.c lv_xml_update.h lv_xml_utils.c lv_xml_utils.h lv_xml_widget.c lv_xml_widget.h
    ../Middleware/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
    ../Middleware/lvgl/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
    ../Middleware/lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
    ../Middleware/lvgl/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
    ../Middleware/lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ../Middleware/lvgl/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
    ../Middleware/lvgl/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
    ../Middleware/lvgl/src/widgets/animimage/: lv_animimage.c lv_animimage.h lv_animimage_private.h
    ../Middleware/lvgl/src/widgets/arc/: lv_arc.c lv_arc.h lv_arc_private.h
    ../Middleware/lvgl/src/widgets/bar/: lv_bar.c lv_bar.h lv_bar_private.h
    ../Middleware/lvgl/src/widgets/button/: lv_button.c lv_button.h lv_button_private.h
    ../Middleware/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
    ../Middleware/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_chinese.c lv_calendar_chinese.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h lv_calendar_private.h
    ../Middleware/lvgl/src/widgets/canvas/: lv_canvas.c lv_canvas.h lv_canvas_private.h
    ../Middleware/lvgl/src/widgets/chart/: lv_chart.c lv_chart.h lv_chart_private.h
    ../Middleware/lvgl/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
    ../Middleware/lvgl/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
    ../Middleware/lvgl/src/widgets/image/: lv_image.c lv_image.h lv_image_private.h
    ../Middleware/lvgl/src/widgets/imagebutton/: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
    ../Middleware/lvgl/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
    ../Middleware/lvgl/src/widgets/label/: lv_label.c lv_label.h lv_label_private.h
    ../Middleware/lvgl/src/widgets/led/: lv_led.c lv_led.h lv_led_private.h
    ../Middleware/lvgl/src/widgets/line/: lv_line.c lv_line.h lv_line_private.h
    ../Middleware/lvgl/src/widgets/list/: lv_list.c lv_list.h
    ../Middleware/lvgl/src/widgets/lottie/: lv_lottie.c lv_lottie.h lv_lottie_private.h
    ../Middleware/lvgl/src/widgets/menu/: lv_menu.c lv_menu.h lv_menu_private.h
    ../Middleware/lvgl/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
    ../Middleware/lvgl/src/widgets/roller/: lv_roller.c lv_roller.h lv_roller_private.h
    ../Middleware/lvgl/src/widgets/scale/: lv_scale.c lv_scale.h lv_scale_private.h
    ../Middleware/lvgl/src/widgets/slider/: lv_slider.c lv_slider.h lv_slider_private.h
    ../Middleware/lvgl/src/widgets/span/: lv_span.c lv_span.h lv_span_private.h
    ../Middleware/lvgl/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
    ../Middleware/lvgl/src/widgets/spinner/: lv_spinner.c lv_spinner.h
    ../Middleware/lvgl/src/widgets/switch/: lv_switch.c lv_switch.h lv_switch_private.h
    ../Middleware/lvgl/src/widgets/table/: lv_table.c lv_table.h lv_table_private.h
    ../Middleware/lvgl/src/widgets/tabview/: lv_tabview.c lv_tabview.h lv_tabview_private.h
    ../Middleware/lvgl/src/widgets/textarea/: lv_textarea.c lv_textarea.h lv_textarea_private.h
    ../Middleware/lvgl/src/widgets/tileview/: lv_tileview.c lv_tileview.h lv_tileview_private.h
    ../Middleware/lvgl/src/widgets/win/: lv_win.c lv_win.h lv_win_private.h
  group Middleware/LVGL/Porting
    ../Middleware/lvgl/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h lv_port_fs.c lv_port_fs.h
  group Middleware/Ymodem
    ../Middleware/Ymodem/: ymodem.c ymodem.h
  group BSP/Board
    ../BSP/Board/: bsp_backlight.c bsp_backlight.h bsp_board.c bsp_board.h bsp_config.h bsp_led.c bsp_led.h bsp_lfs.c bsp_lfs.h bsp_logger.c bsp_logger.h bsp_shell.c bsp_shell.h bsp_storage.c bsp_storage.h bsp_uart.c bsp_uart.h bsp_sensor.c bsp_sensor.h bsp_power.c bsp_power.h bsp_imu.c bsp_imu.h bsp_ec11.c bsp_ec11.h bsp_file.c bsp_file.h
  group BSP/Interface
    ../BSP/Interface/: bsp_interface.h port_critical.c port_critical.h port_dwt.c port_dwt.h port_gpio.c port_gpio.h port_i2c.c port_i2c.h port_pwm.c port_pwm.h port_spi.c port_spi.h port_tick.c port_tick.h port_uart.c port_uart.h soft_i2c.c soft_i2c.h port_adc.c port_adc.h port_sdio.c port_sdio.h
  group BSP/Driver
    ../BSP/Driver/: bsp_driver.h dev_buzzer.c dev_buzzer.h dev_ft6336.c dev_ft6336.h dev_key.c dev_key.h dev_led.c dev_led.h dev_pca9555.c dev_pca9555.h dev_st7789.c dev_st7789.h dev_w25q.c dev_w25q.h dev_ws2812.c dev_ws2812.h dev_sd3078.c dev_sd3078.h dev_icm42688.c dev_icm42688.h dev_ec11.c dev_ec11.h dev_potentiometer.c dev_potentiometer.h
  group BSP/Driver/LibDriver/AT24Cxx
    ../BSP/Driver/LibDriver/AT24Cxx/src/: driver_at24cxx.c driver_at24cxx.h
    ../BSP/Driver/LibDriver/AT24Cxx/example/: driver_at24cxx_basic.c driver_at24cxx_basic.h
    ../BSP/Driver/LibDriver/AT24Cxx/interface/: driver_at24cxx_interface.c driver_at24cxx_interface.h
  group BSP/Driver/LibDriver/AHT20
    ../BSP/Driver/LibDriver/AHT20/src/: driver_aht20.c driver_aht20.h
    ../BSP/Driver/LibDriver/AHT20/interface/: driver_aht20_interface.c driver_aht20_interface.h
    ../BSP/Driver/LibDriver/AHT20/example/: driver_aht20_basic.c driver_aht20_basic.h
  group BSP/Driver/LibDriver/INA226
    ../BSP/Driver/LibDriver/INA226/src/: driver_ina226.c driver_ina226.h
    ../BSP/Driver/LibDriver/INA226/interface/: driver_ina226_interface.c driver_ina226_interface.h
    ../BSP/Driver/LibDriver/INA226/example/: driver_ina226_basic.c driver_ina226_basic.h
  group APP
    ../APP/: app_main.c app_main.h
  group APP/tasks
    ../APP/tasks/: app_sys_monitor.c app_sys_monitor.h app_tasks.h
  group APP/demos
    ../APP/demos/: app_demos.h app_flash_demo.c app_flash_demo.h app_lcd_demo.c app_lcd_demo.h app_lcd_touch_demo.c app_lcd_touch_demo.h app_multibutton_demo.c app_multibutton_demo.h app_rgb_demo.c app_rgb_demo.h app_shell_demo.c app_shell_demo.h app_spi_demo.c app_spi_demo.h app_storage_demo.c app_storage_demo.h app_touch_demo.c app_touch_demo.h app_uart_demo.c app_uart_demo.h app_lvgl_fs_demo.c app_lvgl_fs_demo.h app_rtc_demo.c app_rtc_demo.h app_sensor_demo.c app_sensor_demo.h app_power_demo.c app_power_demo.h app_imu_demo.c app_imu_demo.h app_ec11_demo.c app_ec11_demo.h app_adc_demo.c app_adc_demo.h app_fatfs_demo.c app_fatfs_demo.h app_ymodem_demo.c app_ymodem_demo.h
software components: CMSIS:CORE 4.3.0
